Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-04-08T08:53:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.30.41
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Fri Apr 08 08:53:52 2022* Host: NCL-PI02* Database: C:\Users\connm\AppData\Local\Temp\{F9FF36C2-A8B9-44F1-9E96-FF8C3CCEF627}\ifc* Database version: 5507* Database creation date: Fri Apr 08 08:53:52 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Fri Apr 08 08:53:52 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Fri Apr 08 08:53:52 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFurnishingElement: ElementsStrikingTowelHookTVA152011000, NBS_VilleroyAndBochAG_ClthsHks_Elements_Striking_TowelHook_TVA152011000:ElementsStrikingTowelHookTVA152011000:83807
In: Level 1
Type - ElementType: ElementsStrikingTowelHookTVA152011000; Classification: Pr_40_30_78_15 (Uniclass2015); Material: NBS_VilleroyAndBochAG_Chrome
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_ClothesHooks_Elements_Striking_TowelHook_TVA152011000; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/b0gsojom; ProductInformation: n/a; Uniclass2015Title: Clothes hooks; Uniclass2015Code: Pr_40_30_78_15; Uniclass2015Version: Products v1.22; Version: 2
Type - NBS_Data - Colour: Chrome.,Brushed Nickel Matt.,English Gold.,Brushed Gold.,Matt Black; ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; EmbodiedCarbon: n/a; Form: Towel hook; IntegralAccessories: n/a; Recyclability: n/a; RecycledContent: n/a
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_30_78_15:Clothes hooks; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: n/a; Material: Brass; ModelNumber: TVA152011000; ModelReference: Elements Striking Towel Hook TVA152011000; Name: ClothesHooks_Elements_Striking_TowelHook_TVA152011000_VilleroyAndBochAG; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; Barcode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
